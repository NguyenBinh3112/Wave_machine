<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Wave_create_machine.ewp</path>
  </project>
  <batchBuild />
</workspace>
